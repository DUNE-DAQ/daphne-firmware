FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-accept-current-sm-k26-fru-prefix.patch"
